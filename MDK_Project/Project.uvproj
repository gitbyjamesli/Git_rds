# Keil uVision project Project.uvproj, settings and files
target Target1 (ARM-ADS)
  device: STM32F103RE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: RDS_发射板 +hex
  c flags: OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD
  c include: ..\;..\..\STM32F10x_StdPeriph_Lib_V3.5.0\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\..\STM32F10x_StdPeriph_Lib_V3.5.0\Libraries\CMSIS\CM3\CoreSupport;..\..\STM32F10x_StdPeriph_Lib_V3.5.0\Libraries\STM32F10x_StdPeriph_Driver\inc;..\..\STM32F10x_StdPeriph_Lib_V3.5.0\Utilities\STM32_EVAL;..\li_code
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group 启动代码
    ../../STM32F10x_StdPeriph_Lib_V3.5.0/Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_md.s
  group CMSIS(内核相关)
    ../: system_stm32f10x.c
    ../../STM32F10x_StdPeriph_Lib_V3.5.0/Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
  group 固件库V3.5.0
    ../../STM32F10x_StdPeriph_Lib_V3.5.0/Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_exti.c stm32f10x_pwr.c stm32f10x_rtc.c stm32f10x_bkp.c stm32f10x_adc.c stm32f10x_dma.c
  group RTX系统配置
    ../: RTX_Conf_CM.c
  group 用户文件
    ../: mainV1.c LCD19264 DriverV20.c DrawPicture.c PT2314.c QN8027_Driver.c stm32f10x_it.c show.c anjian.c DAC5615.c 24c32.c
  group 小李的代码
    ../li_code/: app.c adc.c
